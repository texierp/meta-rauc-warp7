FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

dirs755_append = " /data"
